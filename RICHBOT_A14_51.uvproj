# Keil uVision project RICHBOT_A14_51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RICHBOT_A14_51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\System
  group User
    ./User/: main.c global.h config.h track_test.h turn90_test.h
  group Driver
    ./Driver/: OLED.c InfraredDriver.c Avoid.c Buzzer.c Motor.c Track.c Uart.c Ultra.c
  group System
    ./System/: gpio.c RICHBOT_timer.c PCA.c USART.C
